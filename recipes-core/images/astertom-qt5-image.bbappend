IMAGE_INSTALL_remove += " qtlocation qtlocation-plugins qtlocation-qmlplugins"