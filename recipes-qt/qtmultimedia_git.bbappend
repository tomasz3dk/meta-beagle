PACKAGECONFIG_remove = " gstreamer"